Commit message: added a variety of fixes for integrationg

File: rocket_league_simulation/urdf/car.urdf (robot description, URDF)
Before this commit: robot simplecar, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.13 0.28 0.1; visual box size=0.13 0.28 0.1
