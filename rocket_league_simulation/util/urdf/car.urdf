Commit message: floor fitting and car dimension changes

File: rocket_league_simulation/util/urdf/car.urdf (robot description, URDF)
Before this commit: robot simplecar, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=.3 0.15 0.1; visual box size=0.28 0.13 0.1
