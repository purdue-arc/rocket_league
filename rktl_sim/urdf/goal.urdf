Commit message: shortened goal

File: rktl_sim/urdf/goal.urdf (robot description, URDF)
Before this commit: robot goal, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.05 1.0 0.25; visual box size=0.05 1.0 0.25
